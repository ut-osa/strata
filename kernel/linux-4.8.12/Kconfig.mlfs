## kernel/linux-4.8.12/Kconfig.mlfs
```kconfig
menu "MLFS"

config MLFS
	tristate "Enable performance model for EXT4-DAX"
	default y

endmenu
```
